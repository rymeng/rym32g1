<?xml version="1.0" encoding="utf-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\uart_redirect_stdout.ewp</path>
  </project>
  <batchBuild />
</workspace>