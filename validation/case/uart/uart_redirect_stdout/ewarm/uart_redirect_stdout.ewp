# IAR project uart_redirect_stdout.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\application\include; ..\..\..\..\bsp\include; ..\..\..\..\lib\cmsis\core\include; ..\..\..\..\lib\cmsis\device\include; ..\..\..\..\lib\device\include; ..\..\..\..\lib\hal\include; ..\..\..\..\middlewares\ufifo\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_redirect_stdout.hex
  ILINK.IlinkOutputFile: uart_redirect_stdout.out
  ILINK.IlinkIcfFile: ..\..\..\..\linker\ewarm\rym32g1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../application/src/: main.c
  group lib/bsp
    ../../../../bsp/src/: board_clk.c board_delay.c board_print.c board_systick.c
  group lib/cmsis/device
    ../../../../lib/cmsis/device/src/: startup_rym32g1.c system_rym32g1.c
  group lib/middlewares/ufifo
    ../../../../middlewares/ufifo/src/: ufifo.c
