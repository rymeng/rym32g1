# Keil uVision project uart_redirect_stdout.uvprojx, settings and files
target uart_redirect_stdout (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: uart_redirect_stdout +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\application\include;..\..\..\..\bsp\include;..\..\..\..\lib\cmsis\core\include;..\..\..\..\lib\cmsis\device\include;..\..\..\..\lib\device\include;..\..\..\..\lib\hal\include;..\..\..\..\middlewares\ufifo\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\linker\mdk\rym32g1.sct
  group application
    ../application/src/: main.c
  group lib/bsp
    ../../../../bsp/src/: board_clk.c board_delay.c board_print.c board_systick.c
  group lib/cmsis/device
    ../../../../lib/cmsis/device/src/: startup_rym32g1.c system_rym32g1.c
  group lib/middlewares/ufifo
    ../../../../middlewares/ufifo/src/: ufifo.c
