# IAR project rym32g1-flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..\..\application\include; ..\..\lib\bsp\include; ..\..\lib\cmsis\core\include; ..\..\lib\cmsis\device\include; ..\..\lib\hal\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rym32g1-flashloader.srec
  ILINK.IlinkOutputFile: rym32g1_flash_bank.out
  ILINK.IlinkIcfFile: linker-file\rym32g1-flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  group application
    ../../application/src/: algorithm.c framework.c framework_entry.s
  group lib/bsp
    ../../lib/bsp/src/: board.c
