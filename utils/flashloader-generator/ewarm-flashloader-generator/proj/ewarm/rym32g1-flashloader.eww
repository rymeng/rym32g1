<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rym32g1-flashloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
